# Keil uVision project black3.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: black3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\OLED
  group Source Group 1
    ./: STARTUP.A51 main.c ADC.c
  group OLED
    ./OLED/: bmp.h oled.c oled.h oledfont.h
